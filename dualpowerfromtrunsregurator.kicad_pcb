# Repository bananagunso/dualpowerfromtrunsregurator

## KiCad design dualpowerfromtrunsregurator.kicad_pcb

Parts:
C1, C2: 1000uF; CP_Radial_D10.0mm_P5.00mm
C3: 01uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C4, C5, C6, C7, C8: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C9, C10, C11: 47uF; CP_Radial_D7.5mm_P2.50mm
D1, D2, D3, D4: 1N914; D_DO-34_SOD68_P7.62mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: 0v; PinHeader_1x01_P2.54mm_Vertical
J2: 12v; PinHeader_1x01_P2.54mm_Vertical
J3: 24v; PinHeader_1x01_P2.54mm_Vertical
J4: +15v2; PinHeader_1x01_P2.54mm_Vertical
J5: GND2; PinHeader_1x01_P2.54mm_Vertical
J6: +15v; PinHeader_1x01_P2.54mm_Vertical
J7: GND; PinHeader_1x01_P2.54mm_Vertical
J8: -15v; PinHeader_1x01_P2.54mm_Vertical
U1: 7815; TO-220-3_Vertical
U2: 78L15; TO-92_Inline
U3: 79L15; TO-92_Inline

Connections:
unnamed: C2.2, C5.2, D1.2 (A), D2.2 (A), U3.2 (VI)
unnamed: D1.1 (K), D3.2 (A), J1.1 (Pin_1_1)
unnamed: D2.1 (K), D4.2 (A), J3.1 (Pin_1_1)
unnamed: C1.1, C3.1, C4.1, D3.1 (K), D4.1 (K), U1.1 (VI), U2.3 (VI)
unnamed: C1.2, C2.1, C3.2, C4.2, C5.1, C6.2, C7.1, C8.2, C9.2, C10.2, C11.1, J2.1 (Pin_1_1), J5.1 (Pin_1_1), J7.1 (Pin_1_1), U1.2 (GND), U2.2 (GND), U3.1 (GND)
unnamed: C8.1, C9.1, J4.1 (Pin_1_1), U1.3 (VO)
unnamed: C6.1, C10.1, J6.1 (Pin_1_1), U2.1 (VO)
unnamed: C7.2, C11.2, J8.1 (Pin_1_1), U3.3 (VO)

Notes on the sheet:
各ジャックのプラスとマイナスの間には0.1uFの積セラを付ける

Board: 2 copper layers, 65.0 x 45.0 mm, 30 parts (0 on the bottom side), 8 nets.
